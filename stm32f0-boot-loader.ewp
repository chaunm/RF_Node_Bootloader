# IAR project stm32f0-boot-loader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F030K6 ST STM32F030K6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: STM32F030; FLASH_32K; FLASH_PAGE_1K; USE_STDPERIPH_DRIVER
  ICCARM.PreInclude: Platform\types.h
  ICCARM.CCIncludePath2: ; \CMSIS; CMSIS\Include; hardware\flash; hardware\system; STM32F0xx_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f030-boot-loader.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_F091 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F091RC ST STM32F091RC
  ICCARM.CCDefines: STM32F091; FLASH_256K; FLASH_PAGE_2K; USE_STDPERIPH_DRIVER
  ILINK.IlinkKeepSymbols: APP
  ILINK.IlinkIcfFile: CMSIS\stm32f091xC_image.icf
  group (top)
    ./: bootloader.c bootloader.h main.c partition.h
    CMSIS/: stm32f091xC_image.icf
  group CMSIS
    CMSIS/: startup_stm32f030x6.s startup_stm32f091.s stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group CMSIS/include
    CMSIS/Include/: arm_common_tables.h arm_const_structs.h arm_math.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h core_sc000.h core_sc300.h
  group hardware/flash
    hardware/Flash/: flash.c flash.h
  group hardware/system
    hardware/System/: system.c system.h
  group STM32F0xx_StdPeriph_Driver/inc
    STM32F0xx_StdPeriph_Driver/inc/: stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_cec.h stm32f0xx_comp.h stm32f0xx_crc.h stm32f0xx_crs.h stm32f0xx_dac.h stm32f0xx_dbgmcu.h stm32f0xx_dma.h stm32f0xx_exti.h stm32f0xx_flash.h stm32f0xx_gpio.h stm32f0xx_i2c.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_pwr.h stm32f0xx_rcc.h stm32f0xx_rtc.h stm32f0xx_spi.h stm32f0xx_syscfg.h stm32f0xx_tim.h stm32f0xx_usart.h stm32f0xx_wwdg.h
  group STM32F0xx_StdPeriph_Driver/src
    STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_flash.c stm32f0xx_gpio.c
